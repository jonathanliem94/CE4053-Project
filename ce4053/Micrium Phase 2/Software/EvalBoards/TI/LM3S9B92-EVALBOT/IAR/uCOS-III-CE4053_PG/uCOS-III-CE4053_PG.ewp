# IAR project uCOS-III-CE4053_PG.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LM3S9B92 TexasInstruments LM3S9B92
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; TARGET_IS_TEMPEST_RB1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\BSP; ..\CFG; ..\..\..\..\..\CPU\LuminaryMicro\DriverLib; ..\..\..\..\..\CPU\LuminaryMicro\DriverLib\driverlib; ..\..\..\..\..\CPU\LuminaryMicro\DriverLib\inc; ..\..\..\..\..\uC-LIB; ..\..\..\..\..\uC-CPU; ..\..\..\..\..\uC-CPU\ARM-Cortex-M3\IAR; ..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\..\..\..\uCOS-III\Source; ..\..\..\..\..\uC-Probe\Target\Communication\Generic\Source; ..\..\..\..\..\uC-Probe\Target\Communication\Generic\RS-232\Source; ..\..\..\..\..\uC-Probe\Target\Communication\Generic\RS-232\Ports\LuminaryMicro\LM3Sxxxx; C:\Users\nickm\OneDrive\Documents\NTU\Year 3\Semester 2\CE4053 Embedded OS\Lab (Free Access)\Repository\ce4053\Micrium Phase 2\Software\uC-Probe\Target\Communication\Generic\Source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uCOS-III-CE4053_PG.bin
  ILINK.IlinkOutputFile: uCOS-III-Ex4.out
  ILINK.IlinkIcfFile: ..\BSP\LM3S9B92_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ./: app.c app_vect.c includes.h os_app_hooks.c os_app_hooks.h
  group APP/CFG
    ./: app_cfg.h os_cfg_app.h
  group APP/EXT
    ext/: cmdline.h diskio.h fatfs.c ff.h integer.h microsd.c SD_Card.h ssi_hw.h
  group BSP
    ../BSP/: LM3S9B92_Flash.icf
  group BSP/Headers
    ../BSP/: bsp.h bsp_dac.h bsp_display.h bsp_int.h bsp_io.h bsp_motor.h bsp_sensors.h
  group BSP/Source
    ../BSP/: bsp.c bsp_dac.c bsp_display.c bsp_int.c bsp_io.c bsp_motor.c bsp_sensors.c cpu_bsp.c
  group CFG
    ../CFG/: cpu_cfg.h lib_cfg.h os_cfg.h
  group CPU/DriverLib
    ../../../../../CPU/LuminaryMicro/DriverLib/driverlib/: adc.c adc.h can.c can.h comp.c comp.h cpu_.c cpu_.h debug.h epi.c epi.h ethernet.c ethernet.h flash.c flash.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h i2s.c i2s.h interrupt.c interrupt.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h ssi.c ssi.h sysctl.c sysctl.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
  group CPU/Inc
    ../../../../../CPU/LuminaryMicro/DriverLib/inc/: hw_adc.h hw_can.h hw_comp.h hw_epi.h hw_ethernet.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_i2s.h hw_ints.h hw_memmap.h hw_nvic.h hw_pwm.h hw_qei.h hw_ssi.h hw_sysctl.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h
  group uC/CPU/Headers
    ../../../../../uC-CPU/ARM-Cortex-M3/IAR/: cpu.h
    ../../../../../uC-CPU/: cpu_core.h cpu_def.h
  group uC/CPU/Source
    ../../../../../uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm cpu_c.c
    ../../../../../uC-CPU/: cpu_core.c
  group uC/LIB/Headers
    ../../../../../uC-LIB/: lib_ascii.h lib_def.h lib_math.h lib_mem.h lib_str.h
  group uC/LIB/Source
    ../../../../../uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-III/Headers
    ../../../../../uCOS-III/Source/: os.h os_type.h
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h
  group uC/OS-III/Source
    ./: avltree.c avltree.h heap.c heap.h
    ../../../../../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
